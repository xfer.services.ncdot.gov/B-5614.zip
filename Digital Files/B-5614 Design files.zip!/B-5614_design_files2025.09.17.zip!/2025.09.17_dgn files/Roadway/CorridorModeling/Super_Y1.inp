/* Superelevation Settings and Parameters:
 
Unit System is english.
Created input file "Super_Y1.inp".
Created activity log file "Super_Y1.log".
Created on Tue, Jul 30, 2019 at 13:34.
Using Preference File "rd_pref"
Using e Selection of "4%-30mph".
Using Length Selection of "all cases"
Using Design Speed of 30.000000.
 
*/
 
auto shape
job number = RDY
 
   auto shape set
      shape cluster baseline   = Y1
      shape cluster profile    = Y1
      shape cluster tie        = 0.0000
      dependent shape
      chain  /  offset
         Y1         -10.0000
         Y1         -0.0000
      filler line station / slope
         10+10.000000      2.0000
         10+15.000000      2.0000     /* Curve Y1-1 */
         10+65.000000      0.0000     /* Curve Y1-1 */
         11+15.000000      -2.0000
         11+89.000000      -2.0000
         12+39.000000      0.0000
         12+50.000000      0.4400
 
   auto shape set
      shape cluster baseline   = Y1
      shape cluster profile    = Y1
      shape cluster tie        = 0.0000
      dependent shape
      chain  /  offset
         Y1         0.0000
         Y1         10.0000
      filler line station / slope
         10+10.000000      -2.0000
         10+15.000000      -2.0000     /* Curve Y1-1 */
         10+90.000000      -2.0000     /* Curve Y1-1 */
         11+65.000000      -2.0000
         12+40.000000      -5.0000
         12+50.000000      -5.2800
 
   Plot Parameters
      Dependent Shape
         lvname = Old_Level_63
         co = 6
         lc = 0
         wt = 2
      Dependent Text
      lvname = Old_Level_63
      co = 6
   Independent Shape
      lvname = Old_Level_63
      co = 1
      lc = 0
      wt = 2
   Independent Text
      lvname = Old_Level_63
      co = 1
 
Write shapes into dgn = T:\Projects\NC\Central_Managed_Projects\TIP_PRJ_B\B-5614\Roadway\CorridorModeling\B5614_RDY_CMD.dgn
