/* Superelevation Settings and Parameters:
 
Unit System is english.
Created input file "Super_L.inp".
Created activity log file "Super_L.log".
Created on Tue, Jul 30, 2019 at 09:33.
Using Preference File "rd_pref"
Using e Selection of "6%-60mph".
Using Length Selection of "all cases"
Using Design Speed of 60.000000.
 
*/
 
auto shape
job number = RDY
 
   auto shape set
      shape cluster baseline   = L
      shape cluster profile    = L
      shape cluster tie        = 0.0000
      dependent shape
      chain  /  offset
         L          -10.0000
         L          -0.0000
      filler line station / slope
         11+00.000000      -4.560
         11+14.000000      -4.000
         13+64.000000      6.0000     /* Curve L-1 */
         15+35.000000      6.0000     /* Curve L-1 */
         17+35.000000      -2.0000
         29+00.000000      -2.0000
         30+00.000000      -6.0000     /* Curve L-2 */
         31+75.000000      -6.0000     /* Curve L-2 */
         32+00.000000      -5.0000
        
 
   auto shape set
      shape cluster baseline   = L
      shape cluster profile    = L
      shape cluster tie        = 0.0000
      dependent shape
      chain  /  offset
         L          0.0000
         L          10.0000
      filler line station / slope
         11+00.000000      -0.715
         11+14.000000      -1.0000
         12+39.000000      -6.0000     /* Curve L-1 */
         15+35.000000      -6.0000     /* Curve L-1 */
         16+35.000000      -2.0000
         28+00.000000      -2.0000
         30+00.000000      6.0000     /* Curve L-2 */
         30+25.000000      5.0000     /* Curve L-2 */
         31+75.000000      1.0000
         32+00.000000      0.7620
 
   Plot Parameters
      Dependent Shape
         lvname = Old_Level_63
         co = 6
         lc = 0
         wt = 2
      Dependent Text
      lvname = Old_Level_63
      co = 6
   Independent Shape
      lvname = Old_Level_63
      co = 1
      lc = 0
      wt = 2
   Independent Text
      lvname = Old_Level_63
      co = 1
 
Write shapes into dgn = T:\Projects\NC\Central_Managed_Projects\TIP_PRJ_B\B-5614\Roadway\CorridorModeling\B5614_RDY_CMD.dgn
